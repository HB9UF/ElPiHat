# Repository HB9UF/ElPiHat

File README.md:

# Introduction

The HB9UF EchoLink Hat is a hat for the Raspberry Pi 3 and 4. It is designed to
connect a transceiver to a Raspberry Pi to implement a link transceiver, but
can also be used for APRS and any other application where a radio needs to be
connected to a Pi. The board features a sound card, a DC/DC converter and
some I/O circuitry to interface with the transceiver. A hardware timout-timer
is included to clear the PTT line if the Raspberry Pi asserts PTT indefinitely.

# Sound Card

The sound card is based on a [Cirrus Logic WM8731SEDS Audio CODEC](https://statics.cirrus.com/pubs/proDatasheet/WM8731_v4.9.pdf).
The line input and line output (both stereo) are routed to JST XH connectors.
The I2S bus is routed to the Raspberry Pi expansion header after
series-termination with 33 Ω. The microphone input and headphone output are
left unconnected, but a small header (1 mm pitch) is provided for prototyping.

The sound card works with a Raspbian stock image (see below).

# DC / DC Converter

Since the transceiver will be powered from an external power supply anyway,
it makes sense to derive the supply for the Pi from that same power supply.
The board is therefore equipped with a [RECOM RPM-2.0](https://recom-power.com/pdf/Innoline/RPM-2.0.pdf)
2 A DC/DC converter that can be powered from a wide range of input voltages
(3 V to 17 V). The output voltage can be trimmed with external resistors (R2
and R3). In Rev. 1.0 of the board, the voltage is slightly incrased to 5.1 V.
Rev 1.1 further increases the voltage to 5.25 V. Make sure to read the errata
below if you have Rev. 1.0. Input power is provided with a JST XH connector;
a crowbar circuit takes out the 2 A SMD fuse in a reverse polarity condition.
However, it is critical not to power the Raspberry Pi via the ordinary USB
supply when the Hat is plugged in. Starting from Rev 1.1, the Pi can be
USB-powered with the Hat inserted, but it is critical not to provide power
via the DC/DC converter and the USB power supply simultaneously.

Note that the package of the RECOM part may be difficult to solder by hand,
thus in case you decide to order PCBs from a board manufacturers, yu may
want to order a stencil from them as well.

# I/O circuitry

The PTT line is controlled with GPIO25 on the Raspberry Pi and is active
high. It used to be possible to echo 25 to `/sys/class/gpio/export` and
to then assert PTT manually using `/sys/class/gpio/gpio25/value`. You
can still do that on recent versions of linux, but you have to add 25
to the base of `gpiochip0`, which turns out to be 512+25=537:

```
$ echo 537 > /sys/class/gpio/export
$ cd /sys/class/gpio/gpio537
$ echo 1 > value # Assert PTT
$ echo 0 > value # Clear PTT

```

However, this is not recommended anymore. Instead, you should use `gpiod`:
```
$ gpioset 0 25=1 # Assert PTT
$ gpioset 0 25=0 # Clear PTT

```

This only works as long as the pin is not exported using the deprecated
`sysfs` interface. `gpioinfo` returns a summary of the current state
of all gpio pins.

Asserting PTT activates a transistor configured in open-drain mode, thus the
PTT pin on the JST XH connector is grounded when PTT is asserted, and Hi-Z
otherwise. A 100 Ω series resistor and a diode are used for protection.

[Quasselsperre](https://github.com/HB9UF/Quasselsperre) is used to limit the
duration for which PTT can remain active. This duration is set with the
potentiometer in 15 minutes increments. Values between 15 minutes and 2 hours
can be programmed. The timer is set during startup and the LED flashes once
for each 15 minutes. (I.e. two flashes amount to a timer of 30 minutes).
The timer is only set during startup. The LED starts to blink when the timer
trips, and transmit is disabled until the Raspberry Pi clears PTT. Starting
from Rev. 1.1: In case this facility is not used, the PTT input can be
connected directly to the switching transistor by populating R5.

Please refer to the [README file](https://github.com/HB9UF/Quasselsperre/blob/master/README.md)
of our Quasselsperre project for further information on customizing,
programming etc. In case this feature is undesired, the microcontroller can
be omitted. In this case, you have to bypass the microcontroller with a jumper
bridge.

The board also features a `TOS` line to report Tone Operated Squelch or Carrier
Operated Squelch (TOS/COS) back to the Raspberry Pi. This is routed to GPIO24.
There is some amount of input protection circuitry that can be used to reduce
the voltage to 3.3 V. Remember that the Raspberry Pi is not 5 V tolerant.

# Schematic and BOM

Here is an image of the schematic. A pdf version is available in the Release
section of the github page.

An interactive BOM is available
[here for Rev 1.1](https://htmlpreview.github.io/?https://github.com/HB9UF/ElPiHat/blob/rev1.1/BOM/ibom.html),
and 
[here for Rev 1.0](https://htmlpreview.github.io/?https://github.com/HB9UF/ElPiHat/blob/rev1.0/BOM/ibom.html).
You can use it to populate the board and copy the BOM to the clipboard to order
parts from DigiKey. Note that we keep a local stock of general purpose parts,
thus we only added part numbers for specialized parts.

# Setup

To enable the sound card, add the following entries to `/boot/config.txt`
and reboot the Raspberry Pi:

```
dtparam=i2c_arm=on
dtparam=i2s=on
dtoverlay=i2s-mmap
dtoverlay=rpi-proto
```

# Test

For the first test do not solder the connector sockets to the PCB.

Here is an image of the 40pin Pi-GPIO Connector.

(1) Connect IN to 12VDC (limited to 10mA).
Measure with DMM at Pin2 on 40pin Pi-GPIO Connector: 
- There should be 5.25VDC
- Blue PGOOD/D2 LED should be constant on
- If measured voltage is lower (eg. 4.9VDC), look at R3
- If there is 0VDC, look at FB1

(2) Connect a second 3.3VDC voltage (limited to 10mA) to Pin17 on 40pin Pi-GPIO Connector:
- Red PTT/TOT/D3 LED blinks. 
Disconnect 3.3VDC voltage, change Poti position, connect 3.3VDC voltage again to Pin17.
- Red PTT/TOT/D3 LED blinks different times.
The red PTT/TOT/D3 LED blinks once per 15 minutes Quassesperre.
Threshold can be set here with this Poti.

(3) If everything OK, solder all connecors and 40pin Pi-GPIO Connector

(4) Start Pi with 12VDC via ElPiHat (1A limit) 
Caution! Do not power Pi via USB simultaneously!

(5) As soon Pi has booted:
a) Test COS/PTT functionality with GPIO
The PTT line is controlled with GPIO25 on the Raspberry Pi and is active
high:

```
$ echo 25 > /sys/class/gpio/export
$ echo out > direction
$ cd /sys/class/gpio/gpio25
$ echo 1 > value # Assert PTT
$ echo 0 > value # Clear PTT

```
Asserting PTT activates a transistor configured in open-drain mode, thus the
PTT pin on the JST XH connector is grounded when PTT is asserted, and Hi-Z
otherwise. A 100 Ω series resistor and a diode are used for protection.

b) Enable sound card by adding the following entries to `/boot/config.txt`
and reboot the Raspberry Pi:

```
dtparam=i2c_arm=on
dtparam=i2s=on
dtoverlay=i2s-mmap
dtoverlay=rpi-proto
```
c) Record and (re)play samples to test audio.

1. Start `alsamixer`, hit F6 and activate sound card 1 (`snd_rpi_proto`). Activate the `Output Mixer HiFi` item and set `CAPTURE` for the `Line` item.
2. Run `arecord -V stereo -fdat -D 'hw:CARD=sndrpiproto,DEV=0' > /dev/null` and observe the VU meter while injecting a signal into the left and the right channel. Once this works, arecord can be used to record a sample (e.g.`arecord test.wav`) for playback in the next step.
3. Play back the sample using `aplay -D 'plughw:CARD=sndrpiproto,DEV=0' test.wav`

# License

This project is released under the terms of the CC-BY-SA license. © 2020 - 2021.

## KiCad design el_pi_hat.kicad_pcb

Parts:
C1, C2, C4, C10, C18, C19: 10u; C_0805_2012Metric
C3, C6, C8, C9, C11, C12: 0.1u; C_0603_1608Metric
C5, C7: 22p; C_0603_1608Metric
C13, C14: 1u; C_0603_1608Metric
C15, C20, C21, C22: 220p; C_0603_1608Metric
C16, C17: 220u
D1, D5: B340; D_SMC; DIGIKEY B340-FDICT-ND
D2: PGOOD; LED_0805_2012Metric
D3: PTT; LED_0805_2012Metric
D4: SP0502BAHT; SOT-23; DIGIKEY F2714CT-ND
F1: 2 A; R_1210_3225Metric; DIGIKEY 507-1881-1-ND‎
FB1, FB2, FB3: Ferrite_Bead_Small; R_0603_1608Metric
J1: 12V; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal; DIGIKEY 455-4226-ND
J2: UART; PinHeader_1x03_P1.00mm_Vertical
J3: Raspberry Pi Header; PinSocket_2x20_P2.54mm_Vertical
J4: TRX; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal; DIGIKEY 455-2954-ND
J5: MIC; PinHeader_1x03_P1.00mm_Vertical
J6: LINE OUT; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal; DIGIKEY 455-2954-ND
J7: LINE IN; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal; DIGIKEY 455-2954-ND
J8: HP OUT; PinHeader_1x03_P1.00mm_Vertical
J9: HP OUT
L1: 10u; L_0805_2012Metric; DIGIKEY CV201210-100KCT-ND
Q1, Q2: 2N7002; SOT-23; DIGIKEY ‎1727-8643-1-ND‎
R1, R3, R14, R18, R29: 1M4; R_0603_1608Metric
R2, R5: NP; R_0603_1608Metric
R4, R15, R17, R23, R24, R27, R28: 5.6k; R_0603_1608Metric
R7, R13, R16, R25, R26: 100; R_0603_1608Metric
R8, R9, R10, R11, R12: 33; R_0603_1608Metric
R19, R20: 47k
R21, R22: 47k; R_0603_1608Metric
RV1: 50k; Potentiometer_Bourns_TC33X_Vertical; DIGIKEY 118-TC33X-1-503ECT-ND
U1: RPM5.0-2.0; Converter_DCDC_RECOM_RPMx.x-x.0; DIGIKEY 945-3252-1-ND‎
U2: ATtiny10-TS; SOT-23-6; DIGIKEY ATTINY10-TSHR
U3: WM8731SEDS; SSOP-28_5.3x10.2mm_P0.65mm; DIGIKEY ‎598-2460-ND‎
Y1: 12.88MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm; DIGIKEY RH100-12.288-18-2030-E

Connections:
+3V3: C3.1, C4.1, C6.1, C8.1, J3.17 (3V3), L1.1, R13.2, U2.5 (VCC), U3.1 (DBVDD), U3.27 (DCVDD)
+5V: D5.2 (A), J3.2 (5V), J3.4 (5V), R2.1, U1.A5 (+VOUT), U1.B5 (+VOUT), U1.C5 (Sense)
+12V: C2.1, D2.2 (A), D5.1 (K), FB1.1, U1.A1 (+VIN), U1.A2 (+VIN)
/I2S_BCLK: J3.12 (GPIO18/PWM0), R12.2
/I2S_DIN: J3.38 (GPIO20/MOSI1), R10.2
/I2S_DOUT: J3.40 (GPIO21/SCLK1), R8.2
/I2S_LRCLK: J3.35 (GPIO19/MISO1), R9.2, R11.2
/LHPOUT: C16.1, J8.3, U3.9 (LHPOUT)
/LOUT: C18.1, U3.12 (LOUT)
/PI_PTT: J3.22 (GPIO25), R5.2, R14.1, U2.4 (PB2)
/PI_TOS: C22.1, D4.2 (K), J3.18 (GPIO24), R15.1, R29.2
/RHPOUT: C17.1, J8.2, U3.10 (RHPOUT)
/ROUT: C19.1, U3.13 (ROUT)
/SCL: J3.5 (SCL/GPIO3), U3.24 (SCLK)
/SDA: J3.3 (SDA/GPIO2), U3.23 (SDIN)
/TRX_PTT: C15.1, D4.1 (K), Q2.3 (D), R16.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C15.2, C20.2, C21.2, C22.2, D1.2 (A), D4.3 (A), J1.1, J2.1, J3.6 (GND), J3.9 (GND), J3.14 (GND), J3.20 (GND), J3.25 (GND), J3.30 (GND), J3.34 (GND), J3.39 (GND), J4.1, J5.1, J6.1, J7.1, J8.1, J9.1, Q1.2 (S), Q2.2 (S), R1.2, R3.1, R7.1, R14.2, R18.1, R19.2, R20.2, R21.2, R22.2, R23.2, R24.2, R29.1, RV1.1, U1.A3 (GND), U1.A4 (GND), U1.B1 (GND), U1.B2 (GND), U1.B3 (GND), U1.B4 (GND), U1.C2 (GND), U1.C3 (GND), U1.C4 (GND), U1.D2 (GND), U1.D3 (GND), U1.D4 (GND), U1.D5 (GND), U1.E3 (GND), U1.E4 (GND), U2.2 (GND), U3.11 (HPGND), U3.15 (AGND), U3.21 (MODE), U3.22 (~CSB), U3.28 (DGND)
unnamed: C1.1, D1.1 (K), F1.1, FB1.2
unnamed: C5.1, U3.25 (XTI/MCLK), Y1.1
unnamed: C7.1, U3.26 (XTO), Y1.3
unnamed: C10.1, C11.1, U3.16 (VMID)
unnamed: C9.1, C12.1, L1.2, U3.8 (HPVDD), U3.14 (AVDD)
unnamed: C13.1, U3.20 (LLINEIN)
unnamed: C13.2, C20.1, R23.1, R27.2
unnamed: C14.1, U3.19 (RLINEIN)
unnamed: C14.2, C21.1, R24.1, R28.2
unnamed: C16.2, J9.3, R19.1
unnamed: C17.2, J9.2, R20.1
unnamed: C18.2, R21.1, R25.2
unnamed: C19.2, R22.1, R26.2
unnamed: D2.1 (K), R4.1
unnamed: D3.1 (K), U2.1 (PB0)
unnamed: D3.2 (A), R13.1, RV1.3
unnamed: F1.2, J1.2
unnamed: FB2.1, R15.2
unnamed: FB2.2, J4.3
unnamed: FB3.1, R16.2
unnamed: FB3.2, J4.2
unnamed: J2.2, J3.10 (GPIO15/RXD)
unnamed: J2.3, J3.8 (GPIO14/TXD)
unnamed: J5.2, U3.18 (MICIN)
unnamed: J5.3, U3.17 (MICBIAS)
unnamed: J6.2, R26.1
unnamed: J6.3, R25.1
unnamed: J7.2, R28.1
unnamed: J7.3, R27.1
unnamed: Q1.1 (G), R1.1, U1.D1 (PGood)
unnamed: Q1.3 (D), R4.2
unnamed: Q2.1 (G), R17.1, R18.2
unnamed: R2.2, R3.2, U1.E5 (Trim)
unnamed: R7.2, U3.2 (CLKOUT)
unnamed: R8.1, U3.4 (DACDAT)
unnamed: R9.1, U3.5 (DACLRC)
unnamed: R10.1, U3.6 (ADCDAT)
unnamed: R11.1, U3.7 (ADCLRC)
unnamed: R12.1, U3.3 (BCLK)
unnamed: R5.1, R17.2, U2.3 (PB1)
unnamed: RV1.2, U2.6 (~RESET~/PB3)

Notes on the sheet:
Caps: MLCC 25V, X7R
HB9UF EchoLink Hat Rev. 1.0
Potential extension, not routed on current PCB.
FIXME: Misplaced on PCB
Short to bypass ATtiny.

Board: 2 copper layers, 65.0 x 56.0 mm, 77 parts (3 on the bottom side), 56 nets.

Other parts of the board:
CC-BY-SA-LOGO: Logo_silk_CC-BY-SA_10x4.5mm
GND: GND
GND#2, GND#3, GND#4: GND
OSHW: Symbol_OSHW-Logo_SilkScreen_07Jul2012; Symbol_OSHW-Logo_SilkScreen

## Commit log

2020-09-02 Replacing schematic image with corrected version (polyfuse -> fuse)
2020-09-07 Fixing typo in README. Thanks to HB9OCQ for spotting this one!
2020-09-07 Rewording stencil passage in README file.
2020-09-21 Dropping 3M32 resistor to 1M4.
    The DC/DC converter is currently trimmed to 5.1 V. Since the
    Raspberry Pi can take more than that, we increase the voltage
    to 5.25 V. This appears to be the recommended operating voltage.
    In order to achieve this, a trimming resistor of 1M375 is
    required. We use 1M4. Since we also use this resistor value to
    dissipate stray charge on FET and microcontroller inputs, those
2020-09-21 Adding diode to address case where DC/DC converter is reverse biased
    The datasheet of the DC/DC converter recommends a (normally) reverse
    biased diode across the regulator. This is to prevent damage in case
    the output is at a higher voltage than the input.
    Since this condition would apply if somebody powers the Raspberry Pi
    directly (i.e. not using the hat), it is strongly recommended to add
    the diode.
2020-09-21 Adding ability to short out ATtiny chip
    In case somebody decides not to use the Quaselsperre PTT timeout
    timer watchdog, it would be nice to have a normally unpopulated
    resistor that would connect the PTT input to the PTT output.
    The documentation was updated accordingly.
    Fixes #3.
2020-09-21 Relocating decoupling capacitor for HPVDD.
    The capacitor was misplaced, leading to poor decoupling. While we
    never observed issues in this regard with Rev 1.0, this is still
    a good opportunity to address this.
    Fixes #5.
2020-09-21 Making GND symbols, screw holes and 1 mm pitch connectors virtual.
    That way, the won't show up in the iBOM. See #6.
2020-09-21 Adding "DNP" fields to R2 and R5.
    This is to hide them from the BOM. See #6.
2020-09-21 Fixing wrong BOM syntax for DIGIKEY field in U1
    "DIGIKEY" was used both in the field name as well as in the value.
2020-09-21 Improving Silk Screen text "HB9UF EL Hat". Fixes #7.
2020-09-21 Bumping Rev. from 1.0 to 1.1 in schematic and PCB
2020-09-21 New iBOM for Rev 1.1, We also updated the README file accordingly.
2020-09-21 Updating schematic image to Rev 1.1
2020-09-21 Fixing link to rev 1.1 iBOM in README.md
2020-09-21 Minor rewording of README.md
2020-10-01 Correcting typo in README.md
2021-01-06 new file: Inbetriebnahme-Echolink-Hat.txt Beschreibung Inebtriebnahme
2021-01-09 Changed README.md, added test chapter and Pi Header image
2021-01-09 Added test chapter in README.md and a Pi 40pin header image
2021-02-21 Revised Testing Text according inputs by mweyland
2021-02-21 changes within Markup of README.md
2024-10-16 README update: USe gpiod instead of sysfs

Notices in the files:
el_pi_hat.kicad_pcb:
Rev 1.1, (c) 2020
